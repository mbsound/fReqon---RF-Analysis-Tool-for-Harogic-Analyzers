options:
  parameters:
    generate_options: qt_gui
    id: IQ_streaming
    output_language: python
    title: QPSK Demod
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center_Frequency
    start: '9000'
    step: '100'
    stop: '6300000000'
    value: '1000000000'
  states: {}
- name: decimate_factor
  id: variable
  parameters:
    value: '64'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: reference_level
  id: variable_qtgui_range
  parameters:
    label: Reference_Level
    start: '-50'
    step: '1'
    stop: '23'
    value: '0'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Samp_rate
    start: '110000000'
    step: '1'
    stop: '130000000'
    value: '125000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: analog_agc2_xx_0_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: analog_agc2_xx_0_0_1_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    max_gain: '65536'
    reference: '1'
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 0.0628*0.05
  states: {state: disabled}
- name: digital_costas_loop_cc_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.0008'
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: '1'
    loop_bw: 0.00628*0.3
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {state: disabled}
- name: digital_symbol_sync_xx_0_1_0_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: '0.707'
    loop_bw: '0.0068'
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: htra_source_0
  id: htra_source
  parameters:
    center_freq: center_freq
    data_format: Complex16bit
    decim_factor: DECIM_64
    device_ip: 192.168.1.100
    device_num: '0'
    device_type: USB
    ref_level: reference_level
    sample_rate: samp_rate
  states: {}
- name: htra_source_0_0
  id: htra_source
  parameters:
    center_freq: center_freq
    data_format: Complex16bit
    decim_factor: DECIM_64
    device_ip: 192.168.1.100
    device_num: '0'
    device_type: USB
    ref_level: reference_level
    sample_rate: sample_rate
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,1,1,1
    legend: 'False'
    name: Constellation
    size: '1024'
    type: complex
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,1
    size: '1024'
    type: complex
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,1,1,1
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_eye_sink_x_0_0
  id: qtgui_eye_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 1,1,1,1
    samp_per_symbol: sps
    size: '1024'
    srate: sample_rate/decimate_factor
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimate_factor
    fc: center_freq
    fftsize: '512'
    gui_hint: 1,0,1,2
    label: Power
    legend: 'False'
    name: Spectrum
    type: complex
    units: dBm
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: 0,0,1,1
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,0,1,1
    label1: Ch-I
    label2: Ch-Q
    name: IQvT
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Amplitude(V)
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(sample_rate/1e6)
    fbw: '0.45'
    interp: decimate_factor
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0_1
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    fbw: '0.4'
    interp: 4*symbol_rate*decimate_factor
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: symbol_rate*4
    sym_rate: symbol_rate
    type: fir_filter_ccf
  states: {state: disabled}
- name: root_raised_cosine_filter_0_0_1
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    decim: '1'
    gain: '1'
    ntaps: 11*sps*3
    samp_rate: symbol_rate*4
    sym_rate: symbol_rate
    type: fir_filter_ccf
  states: {}

connections:
- [analog_agc2_xx_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [analog_agc2_xx_0_0_1_0, '0', digital_symbol_sync_xx_0_1_0_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0, '1']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_eye_sink_x_0_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_symbol_sync_xx_0_0, '0', qtgui_const_sink_x_0_0_0_0_0, '0']
- [digital_symbol_sync_xx_0_1_0_0, '0', digital_costas_loop_cc_0_0_0, '0']
- [htra_source_0, '0', blocks_complex_to_float_0, '0']
- [htra_source_0, '0', qtgui_freq_sink_x_0, '0']
- [htra_source_0, '0', rational_resampler_xxx_0_0_1, '0']
- [htra_source_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [htra_source_0_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0_0, '0', root_raised_cosine_filter_0_0, '0']
- [rational_resampler_xxx_0_0_1, '0', root_raised_cosine_filter_0_0_1, '0']
- [root_raised_cosine_filter_0_0, '0', analog_agc2_xx_0_0, '0']
- [root_raised_cosine_filter_0_0_1, '0', analog_agc2_xx_0_0_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
